FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += "file://allow-localversion-mismatch.patch"
