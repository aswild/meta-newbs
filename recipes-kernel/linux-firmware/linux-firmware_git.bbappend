# overlay the firmware binary brcmfmac43430-sdio.bin from meta-raspberrypi
FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
