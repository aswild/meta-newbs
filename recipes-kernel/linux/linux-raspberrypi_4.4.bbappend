# NEWBS Linux 4.4 kernel customizations

require linux-raspberrypi-newbs.inc
