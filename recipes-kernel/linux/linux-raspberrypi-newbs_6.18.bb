LINUX_VERSION = "6.18.64"
SRCREV = "a40f735325391b1705161b07f36ed45e1bf04521"
SRC_URI = "git://github.com/raspberrypi/linux.git;protocol=https;branch=rpi-6.18.y"
LIC_FILES_CHKSUM = "file://COPYING;md5=6bc538ed5bd9a7fc9398086aedcd7e46"

require linux-raspberrypi-newbs.inc
