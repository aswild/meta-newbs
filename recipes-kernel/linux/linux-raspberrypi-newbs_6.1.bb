LINUX_VERSION = "6.1.72"
SRCREV = "db53b52e7a54b6eed59dbbfb6f4b19ac6ed4edb3"
SRC_URI = "git://github.com/raspberrypi/linux.git;protocol=https;branch=rpi-6.1.y"
LIC_FILES_CHKSUM = "file://COPYING;md5=6bc538ed5bd9a7fc9398086aedcd7e46"

require linux-raspberrypi-newbs.inc
