LINUX_VERSION = "6.12.75"
SRCREV = "47d9548fdf3cff7c8fc8cc332d30a9634415b0b1"
SRC_URI = "git://github.com/raspberrypi/linux.git;protocol=https;branch=rpi-6.12.y"
LIC_FILES_CHKSUM = "file://COPYING;md5=6bc538ed5bd9a7fc9398086aedcd7e46"

require linux-raspberrypi-newbs.inc
