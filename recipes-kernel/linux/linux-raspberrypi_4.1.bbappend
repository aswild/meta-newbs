# NEWBS Linux 4.1 kernel customizations

require linux-raspberrypi-newbs.inc
