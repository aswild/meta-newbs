# NEWBS Linux 4.13 kernel

LINUX_VERSION = "4.13.6"
SRCREV = "1e16a536091d8a2c7fbd3f4569df94b528f4d574"
SRC_URI = "git://github.com/raspberrypi/linux.git;protocol=git;branch=rpi-4.13.y"

require linux-raspberrypi-newbs.inc
