LINUX_VERSION = "6.6.78"
SRCREV = "9afba138031d6ee69824935b507cc9339427ddaf"
SRC_URI = "git://github.com/raspberrypi/linux.git;protocol=https;branch=rpi-6.6.y"
LIC_FILES_CHKSUM = "file://COPYING;md5=6bc538ed5bd9a7fc9398086aedcd7e46"

require linux-raspberrypi-newbs.inc
