# NEWBS Linux 4.14 kernel

LINUX_VERSION = "4.14.90"
SRCREV = "6d68e517b3ec73b08f3af96f5859c5d083b66535"
SRC_URI = "git://github.com/raspberrypi/linux.git;protocol=git;branch=rpi-4.14.y"

require linux-raspberrypi-newbs.inc
