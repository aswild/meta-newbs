# don't make python3-dev depend on a bunch of C dev libraries
RRECOMMENDS:python3-dev[nodeprrecs] = "1"
