PROVIDES_append = " virtual/userland"
