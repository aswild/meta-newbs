FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://newbs-busybox.cfg"
